require nodejs_8.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e4d35c6120f175e1fbe5ff908b1cf2d6"

SRC_URI[src.md5sum] = "cdb05982df9299451d257565fe0b0b3a"
SRC_URI[src.sha256sum] = "641a15fa822710ef2dc99793fec48d2a8ef75de0040b86568563d4ab296137ef"
