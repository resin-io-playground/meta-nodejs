require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "9f43c072bc2940ba0bde21646e8012f9"
SRC_URI[src.sha256sum] = "0187d4e4ef00cee2b70b0ad0689100050654f26629775d097b145d0d8727f9a0"
